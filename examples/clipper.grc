options:
  parameters:
    author: zoe
    generate_options: qt_gui
    id: clipper
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amp_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amp_range
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: my_module_myclipper_0
  id: my_module_myclipper
  parameters:
    clipper: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', my_module_myclipper_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [my_module_myclipper_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
